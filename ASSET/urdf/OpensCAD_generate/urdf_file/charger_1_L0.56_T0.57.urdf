Commit message: zzz Alienware update

File: ASSET/urdf/OpensCAD_generate/urdf_file/charger_1_L0.56_T0.57.urdf (robot description, URDF)
Before this commit: robot charger_1_L0.56_T0.57, 1 links, 0 joints
Links:
- link charger_1_L0.56_T0.57Link: mass 0.0 -> 1.0
