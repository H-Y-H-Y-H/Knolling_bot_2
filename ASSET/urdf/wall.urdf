Commit message: zzz alienware update: VAE model

File: ASSET/urdf/wall.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=0.2 0.4 0.001; visual box size=0.2 0.4 0.001
